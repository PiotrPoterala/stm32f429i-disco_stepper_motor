# Keil uVision project stm32f429_step_motor.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PP21d +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F429xx
  c include: .;.\strings;.\threads;..\..\..\PP_library\PP_Parameters_Library;..\..\..\PP_library\PP_StepperMotor_Library;..\..\..\PP_library;..\..\..\PP_library\PP_String_Library;..\..\..\PP_library\PP_Rtos_Library;..\..\..\PP_library\PP_Command_Library
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x2df00
  memory RVCT10: RAM 0x2002df00 size 0x2100
  group Source Group 1
    ./: input_signals.h def_pins.h main.cpp config.cpp stm32f_it.cpp pp_drive_algorithms.cpp pp_rtx5_drive_algorithms.cpp at_tags.h pp_param_general.h pp_rtx5_param_mutex_decorator.h pp_point.h
    ../../../PP_library/PP_Parameters_Library/: pp_param.cpp pp_paramlist.cpp
    ../../../PP_library/: stm32xx.h
    ../../../PP_library/PP_String_Library/: pstring.cpp
  group threads
    ./threads/: vSecondThread.cpp vRealizationFunctionsThread.cpp vReceiveAndInterpretDataFromComUartThread.cpp
    ../../../PP_library/PP_Rtos_Library/: pp_rtos_queue.h pp_rtx5_queue.h
  group stepper_motor
    ../../../PP_library/PP_StepperMotor_Library/: pp_stepper_motor_2clock_driver.cpp pp_control_coordinate_decorator.cpp pp_control_2clock_signals_decorator.cpp pp_motorslist.cpp pp_stepper_motor_driver.h pp_stepper_motor_driver_decorator.h pp_stepper_motor_dir_clock_driver.h pp_rtx5_control_dir_clock_signals_decorator.cpp
  group uart
    ./: pp_rtx5_at_commands_interpreter.cpp
    ../../../PP_library/PP_Rtos_Library/: pp_rtx5_uart_queue.cpp pp_rtos_uart_queue_decorator.h pp_rtos_uart_queue.h
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Device:Startup 2.6.2
